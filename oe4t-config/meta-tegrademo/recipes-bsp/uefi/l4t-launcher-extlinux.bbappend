do_copy_dtb_overlays[depends] += " imx585-overlay:do_deploy tegrademo-devicetree:do_deploy"
